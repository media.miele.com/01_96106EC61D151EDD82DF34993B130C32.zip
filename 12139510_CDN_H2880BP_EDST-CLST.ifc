Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-03-23T15:09:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 23 15:09:05 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\e2056693-f589-4d1a-b179-44e108b70d24\8be99612-7011-476f-a232-a7b5349993ef\ifc * Database version: 5507 * Database creation date: Wed Mar 23 15:09:01 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 23 15:09:01 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 23 15:09:01 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12139510_CDN_H2880BP_EDST-CLST:22288045_CDN_12139510_H2880BP_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22288045_CDN_12139510_H2880BP_EDST-CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22288045_CDN_12139510_H2880BP_EDST-CLST
Type - Pset_ProvisionForVoid - Depth: 626 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 757 mm; Height: 727 mm
